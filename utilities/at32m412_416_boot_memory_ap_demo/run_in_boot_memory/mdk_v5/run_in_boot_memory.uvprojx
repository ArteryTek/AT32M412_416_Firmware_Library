# Keil uVision project run_in_boot_memory.uvprojx, settings and files
target at_start_m412 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M412CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32m412_run_in_boot_memory +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M412CBT7,USE_STDPERIPH_DRIVER,AT_START_M412_V1
  c include: ..\..\..\..\project\at32m412_416_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\libraries\cmsis\cm4\core_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff8000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c run_in_boot_memory.c
  group bsp
    ../../../../project/at32m412_416_board/: at32m412_416_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_gpio.c at32m412_416_usart.c at32m412_416_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group readme
    ../: readme.txt
target at_start_m416 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M416CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.0
  output: at32m416_run_in_boot_memory +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M416CBT7,USE_STDPERIPH_DRIVER,AT_START_M416_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff8000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
