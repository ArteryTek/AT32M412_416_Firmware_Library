# IAR project app_led3_toggle.ewp, settings and files
configuration at_start_m412 (ARM, debug)
  General.OGChipSelectEditMenu: AT32M412CBT7_v2 ArteryTek AT32M412CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32M412CBT7; USE_STDPERIPH_DRIVER; AT_START_M412_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32m412_416_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32M412xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_m416 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32M416CBT7_v2 ArteryTek AT32M416CBT7
  ICCARM.CCDefines: AT32M416CBT7; USE_STDPERIPH_DRIVER; AT_START_M416_V1
  ILINK.IlinkIcfFile: AT32M416xB.icf
  group bsp
    ../../../../../project/at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32m412_416.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group firmware
    ../../../../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_misc.c at32m412_416_tmr.c at32m412_416_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c iap.c main.c tmr.c usart.c
