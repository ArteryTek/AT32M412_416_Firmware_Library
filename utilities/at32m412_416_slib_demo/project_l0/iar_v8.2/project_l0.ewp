# IAR project project_l0.ewp, settings and files
configuration at_start_m412 (ARM, debug)
  General.OGChipSelectEditMenu: AT32M412CBT7_v2 ArteryTek AT32M412CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32M412CBT7; USE_STDPERIPH_DRIVER; AT_START_M412_V1; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\inc; ..\..\..\..\project\at32m412_416_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project_l0.hex
  postbuild: $TOOLKIT_DIR$\bin\isymexport.exe --edit "steering_file.txt" "$TARGET_PATH$" "fir_filter_symbol.o"
  ILINK.IlinkOutputFile: project_l0.out
  ILINK.IlinkIcfFile: AT32M412xB_slib.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration at_start_m416 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32M416CBT7_v2 ArteryTek - AT32M416CBT7
  ICCARM.CCDefines: AT32M416CBT7; USE_STDPERIPH_DRIVER; AT_START_M416_V1; ARM_MATH_CM4
  ILINK.IlinkIcfFile: AT32M416xB_slib.icf
  group bsp
    ../../../../project/at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32m412_416.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group fir_filter
    ../src/: arm_fir_f32.c arm_fir_init_f32.c fir_coefficient.c fir_filter.c
  group firmware
    ../../../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_misc.c at32m412_416_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: arm_fir_data.c at32m412_416_clock.c at32m412_416_int.c main.c math_helper.c
