# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32M412CBT7 ArteryTek
  output: Template +hex
  c flags: Optim=1
  c define: AT32M412CBT7,USE_STDPERIPH_DRIVER,AT_START_M412_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32m412_416_board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c
  group bsp
    ../../../at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
  group firmware
    ../../../../libraries/drivers/src/: at32m412_416_adc.c at32m412_416_can.c at32m412_416_cmp.c at32m412_416_crc.c at32m412_416_crm.c at32m412_416_dac.c at32m412_416_debug.c at32m412_416_dma.c at32m412_416_ertc.c at32m412_416_exint.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_i2c.c at32m412_416_misc.c at32m412_416_op.c at32m412_416_pwc.c at32m412_416_scfg.c at32m412_416_spi.c at32m412_416_tmr.c at32m412_416_usart.c at32m412_416_wdt.c at32m412_416_wwdt.c
  group readme
    ../: readme.txt
