# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32M412CBT7_v2 ArteryTek AT32M412CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32M412CBT7; USE_STDPERIPH_DRIVER; AT_START_M412_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32m412_416_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32m412_416.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group firmware
    ../../../../libraries/drivers/src/: at32m412_416_adc.c at32m412_416_can.c at32m412_416_cmp.c at32m412_416_crc.c at32m412_416_crm.c at32m412_416_dac.c at32m412_416_debug.c at32m412_416_dma.c at32m412_416_ertc.c at32m412_416_exint.c at32m412_416_flash.c at32m412_416_gpio.c at32m412_416_i2c.c at32m412_416_misc.c at32m412_416_op.c at32m412_416_pwc.c at32m412_416_scfg.c at32m412_416_spi.c at32m412_416_tmr.c at32m412_416_usart.c at32m412_416_wdt.c at32m412_416_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c
