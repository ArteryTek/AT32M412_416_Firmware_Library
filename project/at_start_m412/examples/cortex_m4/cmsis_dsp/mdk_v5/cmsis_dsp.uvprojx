# Keil uVision project cmsis_dsp.uvprojx, settings and files
target cmsis_dsp (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M412CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cmsis_dsp +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M412CBT7,USE_STDPERIPH_DRIVER,AT_START_M412_V1,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_LOOPUNROLL
  c include: ..\inc;..\..\..\..\..\at32m412_416_board;..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\dsp\include;..\..\..\..\..\..\libraries\cmsis\dsp\PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: main.c at32m412_416_int.c at32m412_416_clock.c
  group bsp
    ../../../../../at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
  group firmware
    ../../../../../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_gpio.c at32m412_416_misc.c at32m412_416_usart.c
  group cmsis_dsp
    ../../../../../../libraries/cmsis/dsp/source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/BayesFunctions/: BayesFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/CommonTables/: CommonTables.c
    ../../../../../../libraries/cmsis/dsp/source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/ControllerFunctions/: ControllerFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/DistanceFunctions/: DistanceFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/FastMathFunctions/: FastMathFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/FilteringFunctions/: FilteringFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/MatrixFunctions/: MatrixFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/SVMFunctions/: SVMFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/SupportFunctions/: SupportFunctions.c
    ../../../../../../libraries/cmsis/dsp/source/TransformFunctions/: TransformFunctions.c
  group readme
    ../: readme.txt
