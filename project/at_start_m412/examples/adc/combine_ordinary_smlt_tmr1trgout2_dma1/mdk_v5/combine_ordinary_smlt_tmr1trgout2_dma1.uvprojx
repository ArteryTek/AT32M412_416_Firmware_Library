# Keil uVision project combine_ordinary_smlt_tmr1trgout2_dma1.uvprojx, settings and files
target combine_ordinary_smlt_tmr1trgout2_dma1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32M412CBT7 ArteryTek
  pack: ArteryTek.AT32M412_416_DFP.2.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: combine_ordinary_smlt_tmr1trgout2_dma1 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32M412CBT7,USE_STDPERIPH_DRIVER,AT_START_M412_V1
  c include: ..\inc;..\..\..\..\..\at32m412_416_board;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\..\libraries\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32m412_416_clock.c at32m412_416_int.c main.c
  group bsp
    ../../../../../at32m412_416_board/: at32m412_416_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32m412_416_gpio.c at32m412_416_misc.c at32m412_416_crm.c at32m412_416_dma.c at32m412_416_adc.c at32m412_416_usart.c at32m412_416_tmr.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32m412_416.s
  group readme
    ../: readme.txt
