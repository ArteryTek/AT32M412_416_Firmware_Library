# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: AT32M416CBT7_v2 ArteryTek AT32M416CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32M416CBT7; USE_STDPERIPH_DRIVER; AT_START_M416_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32m412_416_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../at32m412_416_board/: at32m412_416_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32m412_416.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32m412_416.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32m412_416_crm.c at32m412_416_gpio.c at32m412_416_misc.c at32m412_416_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32m412_416_int.c at32m412_416_clock.c main.c
